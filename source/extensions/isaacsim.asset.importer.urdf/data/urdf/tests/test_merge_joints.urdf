Commit message: Isaac Sim 5.1.0 Early Developer Release

File: source/extensions/isaacsim.asset.importer.urdf/data/urdf/tests/test_merge_joints.urdf (robot description, URDF)
Before this commit: robot test_merge_joints, 7 links, 6 joints
Links:
- link link_2: mass 10 -> None
